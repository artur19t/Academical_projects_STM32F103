# Keil uVision project first.uvprojx, settings and files
target STM32C8T6 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\HW_Init\Inc;.\HW_Init\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c
  group HW_Init
    ./HW_Init/Src/: hw_gpio.c hw_IT.c button.c
    ./HW_Init/Inc/: hw_gpio.h hw_IT.h button.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
